File: SPI_DISP.kicad_sch (KiCad schematic)
At the start: 1 part, among them J2 DISPLAY

Commit message: update to Kicad v9

File: knobs.kicad_sch (KiCad schematic)
At the start: 11 parts

Commit message: update to Kicad v9
